# Keil uVision project Project_F407.uvprojx, settings and files
target Sentry_Chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\sysInit;..\CONTROL\CAN_receive;..\CONTROL\chassis_behaviour;..\CONTROL\gimbal_behaviour;..\CONTROL\IMU;..\CONTROL\MATH;..\CONTROL\RemoteControl;..\CONTROL\RMMOTOR;..\DEFINE;..\HARDWARE\CAN;..\HARDWARE\IWDG;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\PHOTOELECTRIC;..\HARDWARE\PID;..\HARDWARE\TIME;..\HARDWARE\USART;..\HARDWARE\ADC;..\HARDWARE\PWM;..\HARDWARE\RNG;..\HARDWARE\SENSOR;..\REFEREE;..\TASK\Task_Chassis;..\TASK\Task_Detect;..\TASK\Task_Gimbal;..\TASK\Task_Remote;..\TASK\Task_Safe_check;..\TASK\Task_Start;..\TASK\Task_Test;..\TASK\Task_Fire;..\TASK\Task_Remote;..\CONTROL\MATH\filter;..\CONTROL\MATH\maths;..\CONTROL\MATH\list_of_function;..\CONTROL\CAN_receive;..\CONTROL\AUTOMATIC_STRIKE;..\CONTROL\CAPACITOR;..\CONTROL\DOUBLE_GIMBAL;..\CONTROL\PID;..\REFEREE;..\LIBRARIES\startup;.\Listings;..\LIBRARIES\dsp_lib\Include;..\LIBRARIES\device;..\HARDWARE\FIFO_BUFF;..\HARDWARE\REFEREE_DEAL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../LIBRARIES/startup/: startup_stm32f40_41xxx.s
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group SYSTEM
    ../SYSTEM/sysInit/: SysInit.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PHOTOELECTRIC/: photoelectric.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/SENSOR/: sensor.c
  group Drivers/CMSIS
    ../LIBRARIES/device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group REFEREE
    ../REFEREE/: CRC.c RefereeDeal.c UserReferee.c
  group ALGORITHM
    ../CONTROL/PID/: pid.c
    ../CONTROL/MATH/filter/: filter.c
    ../CONTROL/RMMOTOR/: rmmotor.c
    ../CONTROL/MATH/maths/: maths.c
    ../CONTROL/MATH/list_of_function/: list_of_function.h
    ../HARDWARE/FIFO_BUFF/: fifo_buff.c
  group CONTROL
    ../CONTROL/CAN_receive/: CAN_1_receive.c CAN_2_receive.c
    ../CONTROL/chassis_behaviour/: chassis_behaviour.c
    ../CONTROL/RemoteControl/: RemoteControl.c
    ../CONTROL/CAPACITOR/: Capacitor_control.c
    ../CONTROL/DOUBLE_GIMBAL/: Double_Gimbal.c
  group TASK
    ../TASK/Task_Start/: Task_Start.c
    ../TASK/Task_Chassis/: Task_Chassis.c
    ../TASK/Task_fire/: Task_Fire.c
    ../TASK/Task_Detect/: Task_Detect.c
    ../TASK/Task_Safe_check/: Task_Safecheck.c
    ../TASK/Task_Test/: Task_Test.c
    ../TASK/Task_Remote/: Task_Remote.c
